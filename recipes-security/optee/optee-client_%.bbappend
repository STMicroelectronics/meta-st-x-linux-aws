FILESEXTRAPATHS:prepend := "${THISDIR}/optee-os:"

SRC_URI += "file://367-libckteec-Fix-CK_ULONG-conversions-in-C_GetTokenInfo.patch "

PR = "r1"
